# IAR project 14th_wireless_energy_saving_K60.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DX256xxx10 Freescale MK60DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: LPLD_K60
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 14th_wireless_energy_saving_K60.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class; ..\app\control\inc; ..\app\debug\inc; ..\app\device\inc; ..\app\signal\inc; ..\app\system\inc; ..\app\control\src; ..\app\debug\src; ..\app\device\src; ..\app\signal\src; ..\app\system\src; ..\app\drivers\inc; ..\app\drivers\src; ..\app\charge\inc; ..\app\charge\src; ..\..\..\lib\LPLD\FUNC
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  OBJCOPY.OOCOutputFile: 14th_wireless_energy_saving_K60.bin
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_BOOT_K60DN512.icf
  group app
    ../app/: 14th_wireless_energy_saving.c k60_card.h
  group app/charge/inc
    ../app/charge/inc/: buck.h charge.h circuit.h
  group app/charge/src
    ../app/charge/src/: buck.c charge.c circuit.c
  group app/control/inc
    ../app/control/inc/: direction.h speed.h
  group app/control/src
    ../app/control/src/: direction.c speed.c
  group app/debug/inc
    ../app/debug/inc/: car_test.h display.h flash.h infrared_decode.h oled.h scope.h slave_computer.h tele.h
  group app/debug/src
    ../app/debug/src/: car_test.c display.c flash.c infrared_decode.c oled.c scope.c slave_computer.c tele.c
  group app/device/inc
    ../app/device/inc/: beep.h dir_kbi.h encoder.h led.h motor.h mpu6050.h reed.h switch.h test.h
  group app/device/src
    ../app/device/src/: beep.c dir_kbi.c encoder.c led.c motor.c mpu6050.c reed.c switch.c test.c
  group app/drivers/inc
    ../app/drivers/inc/: adc.h gpio.h gpt.h i2c.h nvic.h pit.h pwm.h rtc.h uart.h
  group app/drivers/src
    ../app/drivers/src/: adc.c gpio.c gpt.c i2c.c nvic.c pit.c pwm.c rtc.c uart.c
  group app/signal/inc
    ../app/signal/inc/: calibration.h double_ranging.h inductor.h kalman.h obstacle.h process.h signal.h
  group app/signal/src
    ../app/signal/src/: calibration.c double_ranging.c inductor.c kalman.c obstacle.c process.c signal.c
  group app/system/inc
    ../app/system/inc/: car_info.h general.h include.h init.h isr.h
  group app/system/src
    ../app/system/src/: car_info.c general.c init.c isr.c
  group lib/common
    ../../../lib/common/: alloc.c assert.c assert.h common.h io.c io.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
  group lib/CPU
    ../../../lib/CPU/: MK60DZ10.h startup_K60.s system_MK60DZ10.c system_MK60DZ10.h
  group lib/LPLD
    ../../../lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/DEV
    ../../../lib/LPLD/DEV/: DEV_LCD.c DEV_LCD.h
  group lib/LPLD/FUNC
    ../../../lib/LPLD/FUNC/: TimeStamp.c TimeStamp.h
  group lib/LPLD/HW
    ../../../lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_CAN.c HW_CAN.h HW_DAC.c HW_DAC.h HW_DMA.c HW_DMA.h HW_ENET.c HW_ENET.h HW_FLASH.c HW_FLASH.h HW_FLEXBUS.c HW_FLEXBUS.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_I2C.c HW_I2C.h HW_LPTMR.c HW_LPTMR.h HW_MCG.c HW_MCG.h HW_NVIC.c HW_NVIC.h HW_PDB.c HW_PDB.h HW_PIT.c HW_PIT.h HW_RTC.c HW_RTC.h HW_SDHC.c HW_SDHC.h HW_SPI.c HW_SPI.h HW_SYSTICK.c HW_SYSTICK.h HW_TSI.c HW_TSI.h HW_UART.c HW_UART.h HW_USB.c HW_USB.h HW_WDOG.c HW_WDOG.h
