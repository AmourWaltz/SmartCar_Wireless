<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\14th_wireless_energy_saving_K60.ewp</path>
  </project>
  <batchBuild/>
</workspace>


